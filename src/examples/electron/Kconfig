## src/examples/electron/Kconfig
```kconfig
menuconfig EXAMPLES_ELECTRON
	bool "electron"
	default n
	---help---
		Enable support for electron
```
